Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Jun-Sofa 2 seater - ver4.ifc
Time: 2024-11-07T15:11:28
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (6)
Name
 | Jun-Sofa 2 seater_0 - ObjectType: SketchupGroup
 | Jun-Sofa 2 seater_1 - ObjectType: SketchupGroup
 | Jun-Sofa 2 seater_2 - ObjectType: SketchupGroup
 | Jun-Sofa 2 seater_3 - ObjectType: SketchupGroup
 | Jun-Sofa 2 seater_4 - ObjectType: SketchupGroup
 | Jun-Sofa 2 seater_5 - ObjectType: SketchupGroup
